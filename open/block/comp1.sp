.topckt CLK_COMP clk clkbo dn dp gt vb vdd vin vinb vintn<2> vintn<1> vintp<2> vintp<1> vss
xm103 clkb clk vdd vdd pch_lvt w=480e-9 l=40e-9
xm30 clk net030 vdd vdd pch_lvt w=3.84e-6 l=40e-9
xm124 clkbo clk vdd vdd pch_lvt w=480e-9 l=40e-9
xm16 v2p vxn vdd _net0 pch_lvt w=2.88e-6 l=40e-9
xm114 d v2n vdd vdd pch_lvt w=1.92e-6 l=40e-9
xm122 dp db vdd vdd pch_lvt w=960e-9 l=40e-9
xm25 vmid v2p vdd vdd pch_lvt w=960e-9 l=40e-9
xm14 net027 d vdd vdd pch_lvt w=480e-9 l=40e-9
xm24 db v2p vdd vdd pch_lvt w=1.92e-6 l=40e-9
xm85 net030 gt vdd vdd pch_lvt w=1.92e-6 l=40e-9
xm6 net031 net027 vdd vdd pch_lvt w=960e-9 l=40e-9
xm8 db d vdd vdd pch_lvt w=1.92e-6 l=40e-9
xm5 d db vdd vdd pch_lvt w=1.92e-6 l=40e-9
xm119 dn d vdd vdd pch_lvt w=960e-9 l=40e-9
xm71 net027 db vdd vdd pch_lvt w=480e-9 l=40e-9
xm9 net030 net031 vdd vdd pch_lvt w=1.92e-6 l=40e-9
xm35 vxn clk vdd vdd pch_lvt w=2.88e-6 l=40e-9
xm73 vxp clk vdd vdd pch_lvt w=2.88e-6 l=40e-9
xm19 v2n vxp vdd _net0 pch_lvt w=2.88e-6 l=40e-9
xm26 vmidb v2n vdd vdd pch_lvt w=960e-9 l=40e-9
xm10 net030 net031 net032 vss nch_lvt w=1.92e-6 l=40e-9
xm69 v1p vintn<1> vss vss nch_lvt w=720e-9 l=40e-9
xm17 net032 gt vss vss nch_lvt w=1.92e-6 l=40e-9
xm116 vxp clk v1p vss nch_lvt w=1.92e-6 l=40e-9
xm102 clkb clk vss vss nch_lvt w=240e-9 l=40e-9
xm120 dn d vss vss nch_lvt w=480e-9 l=40e-9
xm1 db d vmid vss nch_lvt w=1.92e-6 l=40e-9
xm113 vmidb v2n vss vss nch_lvt w=1.92e-6 l=40e-9
xm7 net031 net027 vss vss nch_lvt w=480e-9 l=40e-9
xm28 vss vss v1p vss nch_lvt w=240e-9 l=40e-9
xm70 v1p vinb vss vss nch_lvt w=240e-9 l=40e-9
xm97 net027 clkb net0107 vss nch_lvt w=480e-9 l=40e-9
xm12 net0107 vb vss vss nch_lvt w=1.92e-6 l=40e-9
xm121 dp db vss vss nch_lvt w=480e-9 l=40e-9
xm115 vxn clk v1n vss nch_lvt w=1.92e-6 l=40e-9
xm27 clk net030 vss vss nch_lvt w=1.92e-6 l=40e-9
xm20 v2p vxn vss vss nch_lvt w=1.92e-6 l=40e-9
xm3 d db vmidb vss nch_lvt w=1.92e-6 l=40e-9
xm18 vss vss vss vss nch_lvt w=240e-9 l=40e-9
xm55 v1n vin vss vss nch_lvt w=240e-9 l=40e-9
xm23 vss vss v1n vss nch_lvt w=240e-9 l=40e-9
xm57 v1n vintp<2> vss vss nch_lvt w=2.88e-6 l=40e-9
xm125 clkbo clk vss vss nch_lvt w=240e-9 l=40e-9
xm22 vmid v2p vss vss nch_lvt w=1.92e-6 l=40e-9
xm21 v2n vxp vss vss nch_lvt w=1.92e-6 l=40e-9
xm56 v1n vintp<1> vss vss nch_lvt w=720e-9 l=40e-9
xm68 v1p vintn<2> vss vss nch_lvt w=2.88e-6 l=40e-9
.ends CLK_COMP
